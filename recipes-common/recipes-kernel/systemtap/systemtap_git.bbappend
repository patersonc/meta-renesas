do_configure:prepend () {
	export PYTHON3_CONFIG=${STAGING_DIR_NATIVE}/${bindir}/python3-native/python3-config
}
